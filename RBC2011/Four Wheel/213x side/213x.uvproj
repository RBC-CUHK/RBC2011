# Keil uVision project 213x.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2131 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 213x +hex
  c flags: Optim=1
  c include: .;..\..\..\Library
  asm include: .;..\..\..\Library
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Main
    ./: Startup.s armversion.h main.c fourwheel.c
  group AAL
    ../../../Library/AAL/: aal_213xpwm.c aal_adc.c aal_gpio.c aal_spi.c aal_timer.c aal_uart.c arm_math.c
  group RAL
    ../../../Library/RAL/: ral_encoder.c ral_joystick.c ral_linesensor.c ral_motor.c ral_mux.c ral_odometry.c ral_pid.c ral_servo.c
