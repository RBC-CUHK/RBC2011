# Keil uVision project robocon.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2131 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: robocon +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Main
    ./: Startup.s main.c
  group RAL
    ./RAL/: ral_encoder.c ral_joystick.c ral_linesensor.c ral_motor.c ral_mux.c ral_odometry.c ral_pid.c
  group AAL
    ./AAL/: aal_213xpwm.c aal_adc.c aal_gpio.c aal_timer.c aal_uart.c arm_math.c aal_spi.c armversion.h
